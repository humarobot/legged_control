Commit message: fix:机身转动时的鸡头模式

File: legged_examples/lion_armed_description/lion_armed.urdf (robot description, URDF)
Before this commit: robot lion, 25 links, 24 joints
Joints:
- joint body_arm: limit lower=0 upper=0 effort=0 velocity=0 -> (none)
